# Keil uVision project Blinky.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0-dev4
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G474QETx/STCubeGenerated/Src/: main.c stm32g4xx_it.c
    ./RTE/Device/STM32G474QETx/STCubeGenerated/Inc/: stm32g4xx_it.h
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0-dev4
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:Event Recorder 1.4.0, Device:STM32Cube HAL 1.10.0, Board Support:Buttons 1.0.0, Board Support:Drivers:BUS 1.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:I/O 1.0.0, Board Support:LED 1.0.0
